# Keil uVision project byteToMicrocontroller.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: byteToMicrocontroller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ./: buttons.c leds.c main.c usart2.c
  group Headers
    ./: buttons.h leds.h usart2.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
